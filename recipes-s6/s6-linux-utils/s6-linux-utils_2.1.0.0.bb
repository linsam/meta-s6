require s6-linux-utils.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"

SRC_URI[md5sum] = "fe368efa0111ae2e7aec3081b1053165"
SRC_URI[sha256sum] = "3523ba84ba524198711b2de3edaaf620381a4e95d78ec6d13dcb7aba42397ead"

