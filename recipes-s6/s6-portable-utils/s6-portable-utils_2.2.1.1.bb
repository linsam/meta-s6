require s6-portable-utils.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=d7f013666c13fc6c8d0127687dbfa63b"

SRC_URI[md5sum] = "8b09168cbbe5883ae3f3c536484c4608"
SRC_URI[sha256sum] = "6ae239d2c458a81c92b5d616129e443874f925bf3da02589913a1a3b708c4531"

# s6-portable-utils 2.1.0.0 needs skalibs >= 2.4.0.0
# s6-portable-utils 2.2.1.0 needs skalibs >= 2.5.1.0
# s6-portable-utils 2.2.1.1 needs skalibs >= 2.6.0.0
