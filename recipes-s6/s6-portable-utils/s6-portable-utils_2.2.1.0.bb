require s6-portable-utils.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"

SRC_URI[md5sum] = "e10003258a32fad23e31f89484d8e862"
SRC_URI[sha256sum] = "15b044017a1d24432affa26945793aaf93fff03ad0c0ff10a3a4973277fc009b"

# s6-portable-utils 2.1.0.0 needs skalibs >= 2.4.0.0
# s6-portable-utils 2.2.1.0 needs skalibs >= 2.5.1.0
