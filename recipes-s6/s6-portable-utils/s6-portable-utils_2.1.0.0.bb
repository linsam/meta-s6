require s6-portable-utils.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"

SRC_URI[md5sum] = "b0289aa1c46ede3b036a9cfccf00fbd7"
SRC_URI[sha256sum] = "cde145b7b9d1f1685f271c45c8aed635e74221689bb8ec21a11b3e5a252d1c4e"

# s6-portable-utils 2.1.0.0 needs skalibs >= 2.4.0.0
