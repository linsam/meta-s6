require s6-portable-utils.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=2875ff3bd035b06bc171bb0e55a5f228"

SRC_URI[md5sum] = "bbe42c525319c2dbb2a5efa0cdad6d65"
SRC_URI[sha256sum] = "29baab7ca8d5c97cb5f311f4ad359ecee4ed13249fb51e351f4bbc175de47f18"

# s6-portable-utils 2.1.0.0 needs skalibs >= 2.4.0.0
# s6-portable-utils 2.2.1.0 needs skalibs >= 2.5.1.0
# s6-portable-utils 2.2.1.1 needs skalibs >= 2.6.0.0
# s6-portable-utils 2.2.1.2 needs skalibs >= 2.7.0.0
# s6-portable-utils 2.2.3.0 needs skalibs >= 2.9.3.0
