require s6-portable-utils.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"

SRC_URI[md5sum] = "f6341ba58c9ee5c373e4cb5a617bedfa"
SRC_URI[sha256sum] = "233b7d13766a23661cc7ed5c052f29b9c558c1d516a538a281a17da22a909d4b"

