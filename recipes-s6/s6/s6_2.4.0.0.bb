require s6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"

SRC_URI[md5sum] = "d43d82d23ba2f4a00435648298bccc28"
SRC_URI[sha256sum] = "5e788d5935dbcce76ac9a99cfcf6ee46a2ffb84220c84225df7589e9a3585560"

# s6 2.4.0.0 needs skalibs >= 2.4.0.0  execline >= 2.2.0.0
