require skalibs.inc
SRC_URI[md5sum] = "21000c52f51c1b3266b7cec77ef1c027"
SRC_URI[sha256sum] = "f01a07049d384097864410f9251447ad899db0d17f82cd8ebc6b7000d7783b44"
LIC_FILES_CHKSUM = "file://COPYING;md5=2875ff3bd035b06bc171bb0e55a5f228"
