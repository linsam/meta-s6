require skalibs.inc
SRC_URI[md5sum] = "c960f0b61d44834ae584805e8cde1e80"
SRC_URI[sha256sum] = "aa387f11a01751b37fd32603fdf9328a979f74f97f0172def1b0ad73b7e8d51d"
LIC_FILES_CHKSUM = "file://COPYING;md5=d7f013666c13fc6c8d0127687dbfa63b"
