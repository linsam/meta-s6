require skalibs.inc
SRC_URI[md5sum] = "edcd88590288cdd0fc8dbd417e0d49e9"
SRC_URI[sha256sum] = "0708172bc2ec9825f8a4f312d35f8dcd94da5f291425a598c33c873b3de77df8"
LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"
