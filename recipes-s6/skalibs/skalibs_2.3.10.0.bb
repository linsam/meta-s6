require skalibs.inc
SRC_URI[md5sum] = "51cb8484896c68eb8d167767cdfc702e"
SRC_URI[sha256sum] = "e4d5147941055b2a367794666f773a4b216c3ae83c015a5fcf2cd0498470ea44"
LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"
SRC_URI += " file://configure.patch"
