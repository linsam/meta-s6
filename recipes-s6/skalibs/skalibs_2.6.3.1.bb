require skalibs.inc
SRC_URI[md5sum] = "8cce4be9eca3f8b026107e862bc72c6f"
SRC_URI[sha256sum] = "8508ca00d4e2355e9ec0ec7f4808e98b349999d6732d2f123ac53b4df5260c81"
LIC_FILES_CHKSUM = "file://COPYING;md5=682e28b5c36e2b48d5b0cf2fbe8990f5"
