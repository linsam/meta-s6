require skalibs.inc
SRC_URI[md5sum] = "8cc1dfad59a588ba3956d78c81b5ea0a"
SRC_URI[sha256sum] = "6229fb4fb415699bbff3b446ff44aa5b7fb9c512b83bd68ae4005603afab60cb"
SRC_URI += " file://2.3.9_cross.patch"
LIC_FILES_CHKSUM = "file://COPYING;md5=1500f33d86c4956999052c0e137cd652"
