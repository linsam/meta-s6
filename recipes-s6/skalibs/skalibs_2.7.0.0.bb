require skalibs.inc
SRC_URI[md5sum] = "de26435512337650f6e1bcce3643710d"
SRC_URI[sha256sum] = "96494d76669d2f8622511d5d616b6367801a42683c0bb11a8855114e5ccbd756"
LIC_FILES_CHKSUM = "file://COPYING;md5=682e28b5c36e2b48d5b0cf2fbe8990f5"
