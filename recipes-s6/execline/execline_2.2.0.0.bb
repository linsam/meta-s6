require execline.inc

SRC_URI[md5sum] = "8dc0f40cdbbabd7915e9e7b95544d13e"
SRC_URI[sha256sum] = "93bd744f2e3ad204cb89f147efdc6ca4e622f9c6bfc9895e0b2cb8b0480029de"

LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"

# execline 2.2.0.0 needs skalibs >= 2.4.0.0
