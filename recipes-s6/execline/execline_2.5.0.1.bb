require execline.inc

SRC_URI[md5sum] = "fffc9f3fe0e7611d297a86e478c81ff5"
SRC_URI[sha256sum] = "8d07d14e9e9abb1301e08be271313c4ffa5ddf7248fd262dda19588e78e31049"

LIC_FILES_CHKSUM = "file://COPYING;md5=682e28b5c36e2b48d5b0cf2fbe8990f5"

# execline 2.2.0.0 needs skalibs >= 2.4.0.0
# execline 2.3.0.1 needs skalibs >= 2.5.1.0
# execline 2.3.0.4 needs skalibs >= 2.6.2.0
# execline 2.5.0.1 needs skalibs >= 2.7.0.0
