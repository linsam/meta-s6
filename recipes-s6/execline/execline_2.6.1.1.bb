require execline.inc

SRC_URI[md5sum] = "6ec1bcb862d789021fdd411c719eb57d"
SRC_URI[sha256sum] = "394308f0349f962086a9695ca2bb5ef32cd38e5be6b7cec0b3d0cf35a2b2ba56"

LIC_FILES_CHKSUM = "file://COPYING;md5=2875ff3bd035b06bc171bb0e55a5f228"

# execline 2.2.0.0 needs skalibs >= 2.4.0.0
# execline 2.3.0.1 needs skalibs >= 2.5.1.0
# execline 2.3.0.4 needs skalibs >= 2.6.2.0
# execline 2.5.0.1 needs skalibs >= 2.7.0.0
# execline 2.6.1.1 needs skalibs >= 2.9.3.0
