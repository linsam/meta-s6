require execline.inc

SRC_URI[md5sum] = "1d3ad41036bbd745662916d5197b23f3"
SRC_URI[sha256sum] = "e4bb8fc8f20cca96f4bac9f0f74ebce5081b4b687bb11c79c843faf12507a64b"

LIC_FILES_CHKSUM = "file://COPYING;md5=d7f013666c13fc6c8d0127687dbfa63b"

# execline 2.2.0.0 needs skalibs >= 2.4.0.0
# execline 2.3.0.1 needs skalibs >= 2.5.1.0
# execline 2.3.0.4 needs skalibs >= 2.6.2.0
