require execline.inc

SRC_URI[md5sum] = "cc3271375b89a0e3e4ed7e4b659fefe4"
SRC_URI[sha256sum] = "8a3605a6db73183baa376bf2130e8b7eb75a5b5347c7f9144e520fe86bcb1142"

LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"

