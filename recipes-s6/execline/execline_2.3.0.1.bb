require execline.inc

SRC_URI[md5sum] = "3c36b3782c8bc0fa0ac4d076a3bbf52f"
SRC_URI[sha256sum] = "2bf65aaaf808718952e05c2221b4e9472271e53ebd915c8d1d49a3e992583bf4"

LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"

# execline 2.2.0.0 needs skalibs >= 2.4.0.0
# execline 2.3.0.1 needs skalibs >= 2.5.1.0
