require s6-dns.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"

SRC_URI[md5sum] = "9930142151b6ad2e66610d7b33fab2cf"
SRC_URI[sha256sum] = "06856745aa034a1655b7d8226a4b235579b098c58b6009d92151dedd41b15fc2"

# 2.1.0.0 needs skalibs >= 2.4.0.0
# 2.2.0.0 needs skalibs >= 2.5.0.0
