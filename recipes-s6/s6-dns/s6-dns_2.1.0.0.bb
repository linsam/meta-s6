require s6-dns.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6ff3b66afd85801a2be9d46214f4e7b5"

SRC_URI[md5sum] = "400d1115f249bc64c9f0a0fb43d07906"
SRC_URI[sha256sum] = "8455f3b1edad8f01a1340cb1242c141755729bfd5d71059739eced5c006539ad"

# 2.1.0.0 needs skalibs >= 2.4.0.0
