require s6-dns.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d7f013666c13fc6c8d0127687dbfa63b"

SRC_URI[md5sum] = "94c9cd39742fcac7392ce5ca3533044d"
SRC_URI[sha256sum] = "a828583e48741927c88de3822283c317c792ffc15d5e9043f29625b87ba38740"

# 2.1.0.0 needs skalibs >= 2.4.0.0
# 2.2.0.0 needs skalibs >= 2.5.0.0
# 2.3.0.0 needs skalibs >= 2.6.3.0
