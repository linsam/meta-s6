require s6-rc.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=44134bb2d28ac2ef82e6501b78c10103"

SRC_URI[md5sum] = "4d17dea017a07d0d1b5fc0d0ba5ade41"
SRC_URI[sha256sum] = "d04a8a765740ed55e38a33da3639197f51f83b3e498bdef5bc1d1d322b1acff3"

# s6-rc-0.1.0.0 requires
#    skalibs >= 2.4.0.0,
#    execline >= 2.2.0.0,
#    s6 >= 2.4.0.0
