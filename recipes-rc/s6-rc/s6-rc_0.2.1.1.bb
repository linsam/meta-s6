require s6-rc.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=f92469ca440ddf0417773918c2dba935"

SRC_URI[md5sum] = "44eed1e25c3b6686e58bdea7d20ebb2d"
SRC_URI[sha256sum] = "90dfc5be52ddef25bb25d7450e75bb7d07a31c1b8fe73a8b7232a160ec8abc46"

# s6-rc-0.1.0.0 requires 
#    skalibs >= 2.4.0.0,
#    execline >= 2.2.0.0,
#    s6 >= 2.4.0.0

# s6-rc-0.2.1.1 requires
#    skalibs >= 2.5.1.1
#    execline >= 2.3.0.1
#    s6 >= 2.6.0.0
